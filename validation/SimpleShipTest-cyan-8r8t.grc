options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: HBTS
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4,1,1
    label: HB Test (2-6)
    label0: 'T2: 200MHz'
    label1: 'T3: 600MHz'
    label2: 'T4: 1.2GHz'
    label3: 'T5: 2.7GHz'
    label4: 'T6:  4GHz'
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: TS
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Test Select
    label0: 'T1: Freq Dependance (All Different Freq)'
    label1: 'T2-T6: (Use Second Drop Down)'
    label2: 'T7: HB 9GHz'
    label3: 'T8: LB'
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: amp_all
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Amp Sel
    start: '0'
    step: '100'
    stop: '32000'
    value: '26000'
  states: {}
- name: center_a
  id: variable
  parameters:
    value: (TS==0)*945000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*600000000)+((TS==1)*(HBTS==2)*1200000000)+((TS==1)*(HBTS==3)*2700000000)+((TS==1)*(HBTS==4)*4000000000)+((TS==2)*9000000000)+((TS==3)*17e9)+((TS==4)*15000000)
  states: {}
- name: center_b
  id: variable
  parameters:
    value: (TS==0)*1045000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*600000000)+((TS==1)*(HBTS==2)*1200000000)+((TS==1)*(HBTS==3)*2700000000)+((TS==1)*(HBTS==4)*4000000000)+((TS==2)*9000000000)+((TS==3)*17e9)+((TS==4)*15000000)
  states: {}
- name: center_c
  id: variable
  parameters:
    value: (TS==0)*1145000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*600000000)+((TS==1)*(HBTS==2)*1200000000)+((TS==1)*(HBTS==3)*2700000000)+((TS==1)*(HBTS==4)*4000000000)+((TS==2)*9000000000)+((TS==3)*17e9)+((TS==4)*15000000)
  states: {}
- name: center_d
  id: variable
  parameters:
    value: (TS==0)*1245000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*600000000)+((TS==1)*(HBTS==2)*1200000000)+((TS==1)*(HBTS==3)*2700000000)+((TS==1)*(HBTS==4)*4000000000)+((TS==2)*9000000000)+((TS==3)*17e9)+((TS==4)*15000000)
  states: {}
- name: center_e
  id: variable
  parameters:
    value: (TS==0)*1345000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*600000000)+((TS==1)*(HBTS==2)*1200000000)+((TS==1)*(HBTS==3)*2700000000)+((TS==1)*(HBTS==4)*4000000000)+((TS==2)*9000000000)+((TS==3)*17e9)+((TS==4)*15000000)
  states: {}
- name: center_f
  id: variable
  parameters:
    value: (TS==0)*1445000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*600000000)+((TS==1)*(HBTS==2)*1200000000)+((TS==1)*(HBTS==3)*2700000000)+((TS==1)*(HBTS==4)*4000000000)+((TS==2)*9000000000)+((TS==3)*17e9)+((TS==4)*15000000)
  states: {}
- name: center_g
  id: variable
  parameters:
    value: (TS==0)*1545000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*600000000)+((TS==1)*(HBTS==2)*1200000000)+((TS==1)*(HBTS==3)*2700000000)+((TS==1)*(HBTS==4)*4000000000)+((TS==2)*9000000000)+((TS==3)*17e9)+((TS==4)*15000000)
  states: {}
- name: center_h
  id: variable
  parameters:
    value: (TS==0)*1645000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*600000000)+((TS==1)*(HBTS==2)*1200000000)+((TS==1)*(HBTS==3)*2700000000)+((TS==1)*(HBTS==4)*4000000000)+((TS==2)*9000000000)+((TS==3)*17e9)+((TS==4)*15000000)
  states: {}
- name: freq_all
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Freq Sel
    min_len: '2000'
    start: '-samp_rate/2'
    step: '1000'
    stop: samp_rate/2
    value: samp_rate/20
  states: {}
- name: gain_sel
  id: variable
  parameters:
    value: (TS==0)*0+((TS==1)*(HBTS==0)*0)+((TS==1)*(HBTS==1)*0)+((TS==1)*(HBTS==2)*0)+((TS==1)*(HBTS==3)*0)+((TS==1)*(HBTS==4)*0)+((TS==2)*40)+((TS==3)*70)+((TS==4)*0)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: gain_sel
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 325000000/325
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: MagNumberA
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,4,1,1
    label1: '"Mag A: "'
    type: float
  states: {}
- name: MagNumberB
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,4,1,1
    label1: '"Mag B: "'
    type: float
  states: {}
- name: MagNumberC
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,4,1,1
    label1: '"Mag C: "'
    type: float
  states: {}
- name: MagNumberD
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 4,4,1,1
    label1: '"Mag D: "'
    type: float
  states: {}
- name: MagNumberE
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 5,4,1,1
    label1: '"Mag E: "'
    type: float
  states: {}
- name: MagNumberF
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 6,4,1,1
    label1: '"Mag F: "'
    type: float
  states: {}
- name: MagNumberF_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 7,4,1,1
    label1: '"Mag G: "'
    type: float
  states: {}
- name: MagNumberF_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 8,4,1,1
    label1: '"Mag H: "'
    type: float
  states: {}
- name: Tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,16,4
    label0: Freq Sink
    label1: Time Sink
    num_tabs: '2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_all
    freq: freq_all
    offset: '0'
    phase: '0'
    samp_rate: 'samp_rate '
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_1_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_3
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_2_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_2_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_2_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: magProbeA
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeA_0
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeB
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeB_0
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeC
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeC_0
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeD
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeD_0
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_d
    fftsize: '1024'
    gui_hint: Tab@0:2,3,1,1
    name: '"D"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_c
    fftsize: '1024'
    gui_hint: Tab@0:2,2,1,1
    name: '"C"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_g
    fftsize: '1024'
    gui_hint: Tab@0:3,2,1,1
    name: '"G"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_b
    fftsize: '1024'
    gui_hint: Tab@0:2,1,1,1
    name: '"B"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_f
    fftsize: '1024'
    gui_hint: Tab@0:3,1,1,1
    name: '"F"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_a
    fftsize: '1024'
    gui_hint: Tab@0:2,0,1,1
    name: '"A"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_e
    fftsize: '512'
    gui_hint: Tab@0:3,0,1,1
    name: '"E"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_h
    fftsize: '1024'
    gui_hint: Tab@0:3,3,1,1
    name: '"H"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: Tab@1:2,0,1,1
    label1: ''
    label2: ''
    name: '"A"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:2,1,1,1
    label1: ''
    label2: ''
    name: '"B"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:3,1,1,1
    label1: ''
    label2: ''
    name: '"F"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:2,2,1,1
    label1: ''
    label2: ''
    name: '"C"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:3,2,1,1
    label1: ''
    label2: ''
    name: '"G"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:2,3,1,1
    label1: ''
    label2: ''
    name: '"D"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:3,3,1,1
    label1: ''
    label2: ''
    name: '"H"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:3,0,1,1
    label1: ''
    label2: ''
    name: '"E"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0_3_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    ant1: ''
    ant2: ''
    ant3: ''
    ant4: ''
    ant5: ''
    ant6: ''
    ant7: ''
    center_freq0: center_a
    center_freq1: center_b
    center_freq2: center_c
    center_freq3: center_d
    center_freq4: center_e
    center_freq5: center_f
    center_freq6: center_g
    center_freq7: center_h
    clock_rate: 120e6
    clock_source0: internal
    dev_addr: ''
    dev_args: '"crimson"'
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    gain4: tx_gain
    gain5: tx_gain
    gain6: tx_gain
    gain7: tx_gain
    len_tag_name: ''
    nchan: '8'
    otw: sc16
    samp_rate: samp_rate
    stream_args: sc16
    stream_chans: '[0,1,2,3,4,5,6,7]'
    sync: sync
    type: sc16
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    ant2: ''
    ant3: ''
    ant4: ''
    ant5: ''
    ant6: ''
    ant7: ''
    center_freq0: center_a
    center_freq1: center_b
    center_freq2: center_c
    center_freq3: center_d
    center_freq4: center_e
    center_freq5: center_f
    center_freq6: center_g
    center_freq7: center_h
    clock_rate: '0.0'
    clock_source0: internal
    dev_addr: ''
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    gain4: rx_gain
    gain5: rx_gain
    gain6: rx_gain
    gain7: rx_gain
    nchan: '8'
    rx_agc2: Default
    rx_agc3: Default
    rx_agc4: Default
    rx_agc5: Default
    rx_agc6: Default
    rx_agc7: Default
    samp_rate: samp_rate
    stream_args: sc16
    stream_chans: '[0,1,2,3,4,5,6,7]'
    sync: sync
    type: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '1']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '2']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '3']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '4']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '5']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '6']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '7']
- [blocks_interleaved_short_to_complex_0_0, '0', magProbeD, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', magProbeC, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_interleaved_short_to_complex_0_0_0_0, '0', magProbeC_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_interleaved_short_to_complex_0_0_1, '0', magProbeB, '0']
- [blocks_interleaved_short_to_complex_0_0_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_interleaved_short_to_complex_0_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_1_0, '0', magProbeB_0, '0']
- [blocks_interleaved_short_to_complex_0_0_1_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [blocks_interleaved_short_to_complex_0_0_1_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', magProbeA, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', qtgui_freq_sink_x_0_0_2, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0, '0', magProbeA_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0, '0', qtgui_freq_sink_x_0_0_2_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0, '0', qtgui_time_sink_x_0_3, '0']
- [blocks_interleaved_short_to_complex_0_0_3, '0', magProbeD_0, '0']
- [blocks_interleaved_short_to_complex_0_0_3, '0', qtgui_freq_sink_x_0_0_3, '0']
- [blocks_interleaved_short_to_complex_0_0_3, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_nlog10_ff_0, '0', MagNumberA, '0']
- [blocks_nlog10_ff_0_0, '0', MagNumberB, '0']
- [blocks_nlog10_ff_0_1, '0', MagNumberC, '0']
- [blocks_nlog10_ff_0_1_0, '0', MagNumberD, '0']
- [blocks_nlog10_ff_0_2, '0', MagNumberE, '0']
- [blocks_nlog10_ff_0_2_0, '0', MagNumberF, '0']
- [blocks_nlog10_ff_0_2_0_0, '0', MagNumberF_0, '0']
- [blocks_nlog10_ff_0_2_0_0_0, '0', MagNumberF_0_0, '0']
- [magProbeA, '0', blocks_nlog10_ff_0, '0']
- [magProbeA_0, '0', blocks_nlog10_ff_0_2, '0']
- [magProbeB, '0', blocks_nlog10_ff_0_0, '0']
- [magProbeB_0, '0', blocks_nlog10_ff_0_2_0, '0']
- [magProbeC, '0', blocks_nlog10_ff_0_1, '0']
- [magProbeC_0, '0', blocks_nlog10_ff_0_2_0_0, '0']
- [magProbeD, '0', blocks_nlog10_ff_0_1_0, '0']
- [magProbeD_0, '0', blocks_nlog10_ff_0_2_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_interleaved_short_to_complex_0_0_2, '0']
- [uhd_usrp_source_0_0, '1', blocks_interleaved_short_to_complex_0_0_1, '0']
- [uhd_usrp_source_0_0, '2', blocks_interleaved_short_to_complex_0_0_0, '0']
- [uhd_usrp_source_0_0, '3', blocks_interleaved_short_to_complex_0_0, '0']
- [uhd_usrp_source_0_0, '4', blocks_interleaved_short_to_complex_0_0_2_0, '0']
- [uhd_usrp_source_0_0, '5', blocks_interleaved_short_to_complex_0_0_1_0, '0']
- [uhd_usrp_source_0_0, '6', blocks_interleaved_short_to_complex_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '7', blocks_interleaved_short_to_complex_0_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
