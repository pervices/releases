<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vaunt_fm_dual_wx</value></param>
<param><key>author</key><value>Victor Wollesen</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Vaunt Dual Channel FM Reciever WX</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>max_nouts</key><value>160000</value></param>
<param><key>title</key><value>Dual Channel FM Reciever</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adc_rate</value></param>
<param><key>value</key><value>325000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>aud_decim_A1</value></param>
<param><key>value</key><value>int(round(chan_sr_in_demod_A1/audio_sample_rate))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>aud_decim_A2</value></param>
<param><key>value</key><value>int(round(chan_sr_in_demod_A2/audio_sample_rate))</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>chan_1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>99.9e6</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Channel 1</value></param>
<param><key>max</key><value>107.9e6</value></param>
<param><key>min</key><value>87.9e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>chan_2</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>96.3e6</value></param>
<param><key>grid_pos</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Channel 2</value></param>
<param><key>max</key><value>107.9e6</value></param>
<param><key>min</key><value>87.9e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_sr_in_demod_A1</value></param>
<param><key>value</key><value>int(round(adc_rate/(source_decim*filt_decim_A1)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_sr_in_demod_A2</value></param>
<param><key>value</key><value>int(round(adc_rate/(source_decim*filt_decim_A1)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_sr_out_A1</value></param>
<param><key>value</key><value>int(round(chan_sr_in_demod_A1/aud_decim_A1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_sr_out_A2</value></param>
<param><key>value</key><value>int(round(chan_sr_in_demod_A1/aud_decim_A1))</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>chan_width</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>200e3</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Channel Width</value></param>
<param><key>max</key><value>1e6</value></param>
<param><key>min</key><value>50e3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_xlate_A</value></param>
<param><key>value</key><value>chan_1-freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_xlate_A2</value></param>
<param><key>value</key><value>chan_2-freq</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>demod_sr_C1</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>chan_sr_in_demod_A1</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Demod SR (1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_decim_A1</value></param>
<param><key>value</key><value>int(round(source_rate/chan_width))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_decim_A2</value></param>
<param><key>value</key><value>int(round(source_rate/chan_width))</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>97.5e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>WB Centre Freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_rate</value></param>
<param><key>value</key><value>adc_rate/source_decim</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>"Dec 16, RFgain=60, VGA=34, init=937,999"</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>[3,2,1,1]</value></param>
<param><key>label</key><value></value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>chan_sr_out_A1</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Aud SR (1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vol_1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Channel 1 Volume</value></param>
<param><key>max</key><value>11</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>42</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vol_2</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Channel 2 Volume</value></param>
<param><key>max</key><value>11</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>42</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0</value></param>
<param><key>audio_decim</key><value>aud_decim_A1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>chan_sr_in_demod_A1</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_1</value></param>
<param><key>audio_decim</key><value>aud_decim_A2</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>chan_sr_in_demod_A2</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_sample_rate</value></param>
<param><key>label</key><value>Audio Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>chan_sr_out_A1</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>vol_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>vol_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>chan_xlate_A</value></param>
<param><key>decim</key><value>filt_decim_A1</value></param>
<param><key>samp_rate</key><value>int(round(adc_rate/source_decim))</value></param>
<param><key>taps</key><value>firdes.low_pass (1,int(round(adc_rate/source_decim)),75e3,25e3)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1</value></param>
<param><key>center_freq</key><value>chan_xlate_A2</value></param>
<param><key>decim</key><value>filt_decim_A2</value></param>
<param><key>samp_rate</key><value>int(round(adc_rate/source_decim))</value></param>
<param><key>taps</key><value>firdes.low_pass (1,int(round(adc_rate/source_decim)),75e3,25e3)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>source_decim</value></param>
<param><key>label</key><value>source decimation</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>samp_rate</key><value>source_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value>sc16</value></param>
<param><key>stream_chans</key><value>[0]</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>dynamic_range</key><value>70</value></param>
<param><key>fft_rate</key><value>6</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,4,1</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>60</value></param>
<param><key>samp_rate</key><value>int(round(adc_rate/source_decim))</value></param>
<param><key>title</key><value>WideBand Spectrum (FM Band)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_fm_demod_cf_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_fm_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1</source_block_id><sink_block_id>analog_fm_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
