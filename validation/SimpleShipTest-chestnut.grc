options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: HBTS
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,4,1,1
    label: HB Test (2-6)
    label0: 'T2: 200MHz'
    label1: 'T3: 2.7GHz'
    label2: 'T4: 4GHz'
    label3: 'T5: 5.5GHz'
    label4: 'T6:  6.5GHz'
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: TS
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,1
    label: Test Select
    label0: 'T1: Freq Dependance (All Different Freq)'
    label1: 'T2-T6: (Use Second Drop Down)'
    label2: 'T7: HB 7.5GHz'
    label3: 'T8: HB 8.5GHz'
    label4: 'T9: LB'
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: amp_all
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Amp Sel
    start: '0'
    step: '100'
    stop: '32000'
    value: '26000'
  states: {}
- name: center_a
  id: variable
  parameters:
    value: (TS==0)*945000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*2700000000)+((TS==1)*(HBTS==2)*4000000000)+((TS==1)*(HBTS==3)*5500000000)+((TS==1)*(HBTS==4)*6500000000)+((TS==2)*7500000000)+((TS==3)*8500000000)+((TS==4)*15000000)
  states: {}
- name: center_b
  id: variable
  parameters:
    value: (TS==0)*1045000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*2700000000)+((TS==1)*(HBTS==2)*4000000000)+((TS==1)*(HBTS==3)*5500000000)+((TS==1)*(HBTS==4)*6500000000)+((TS==2)*7500000000)+((TS==3)*8500000000)+((TS==4)*15000000)
  states: {}
- name: center_c
  id: variable
  parameters:
    value: (TS==0)*1145000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*2700000000)+((TS==1)*(HBTS==2)*4000000000)+((TS==1)*(HBTS==3)*5500000000)+((TS==1)*(HBTS==4)*6500000000)+((TS==2)*7500000000)+((TS==3)*8500000000)+((TS==4)*15000000)
  states: {}
- name: center_d
  id: variable
  parameters:
    value: (TS==0)*1245000000+((TS==1)*(HBTS==0)*200000000)+((TS==1)*(HBTS==1)*2700000000)+((TS==1)*(HBTS==2)*4000000000)+((TS==1)*(HBTS==3)*5500000000)+((TS==1)*(HBTS==4)*6500000000)+((TS==2)*7500000000)+((TS==3)*8500000000)+((TS==4)*15000000)
  states: {}
- name: freq_all
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Freq Sel
    min_len: '2000'
    start: '-samp_rate/2'
    step: '1000'
    stop: samp_rate/2
    value: samp_rate/20
  states: {}
- name: gain
  id: variable
  parameters:
    value: gain_sel
  states: {}
- name: gain_sel
  id: variable_qtgui_range
  parameters:
    label: Gain Sel
    start: '0'
    step: '1'
    stop: '90'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 325000000/325
  states: {}
- name: MagNumberA
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,4,1,1
    label1: '"Mag A: "'
    type: float
  states: {}
- name: MagNumberB
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 4,4,1,1
    label1: '"Mag B: "'
    type: float
  states: {}
- name: MagNumberC
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 5,4,1,1
    label1: '"Mag C: "'
    type: float
  states: {}
- name: MagNumberD
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 6,4,1,1
    label1: '"Mag D: "'
    type: float
  states: {}
- name: Tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,6,4
    label0: Freq Sink
    label1: Time Sink
    num_tabs: '2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_all
    freq: freq_all
    offset: '0'
    phase: '0'
    samp_rate: 'samp_rate '
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_all
    freq: freq_all
    offset: '0'
    phase: '0'
    samp_rate: 'samp_rate '
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_all
    freq: freq_all
    offset: '0'
    phase: '0'
    samp_rate: 'samp_rate '
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_all
    freq: freq_all
    offset: '0'
    phase: '0'
    samp_rate: 'samp_rate '
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: magProbeA
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeB
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeC
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: magProbeD
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.01'
    threshold: '90'
    type: cf
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_d
    fftsize: '1024'
    gui_hint: Tab@0:2,3,1,1
    name: '"D"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_c
    fftsize: '1024'
    gui_hint: Tab@0:2,2,1,1
    name: '"C"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_b
    fftsize: '1024'
    gui_hint: Tab@0:2,1,1,1
    name: '"B"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_freq_sink_x_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_a
    fftsize: '1024'
    gui_hint: Tab@0:2,0,1,1
    name: '"A"'
    showports: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '75'
    ymin: '-20'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: Tab@1:2,0,1,1
    label1: ''
    label2: ''
    name: '"A"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:2,1,1,1
    label1: ''
    label2: ''
    name: '"B"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:2,2,1,1
    label1: ''
    label2: ''
    name: '"C"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Tab@1:2,3,1,1
    label1: ''
    label2: ''
    name: '"D"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0_3_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    ant1: ''
    ant2: ''
    ant3: ''
    center_freq0: center_a
    center_freq1: center_b
    center_freq2: center_c
    center_freq3: center_d
    clock_rate: 120e6
    clock_source0: internal
    dev_addr: ''
    dev_args: '"chestnut"'
    gain0: '30'
    gain1: '30'
    gain2: '30'
    gain3: '30'
    len_tag_name: ''
    nchan: '4'
    otw: sc16
    samp_rate: samp_rate
    stream_args: sc16
    stream_chans: '[0,1,2,3]'
    sync: sync
    type: sc16
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    ant2: ''
    ant3: ''
    center_freq0: center_a
    center_freq1: center_b
    center_freq2: center_c
    center_freq3: center_d
    clock_rate: '0.0'
    clock_source0: internal
    dev_addr: ''
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    stream_args: sc16
    stream_chans: '[0,1,2,3]'
    sync: sync
    type: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_complex_to_interleaved_short_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_complex_to_interleaved_short_0_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_complex_to_interleaved_short_0_0_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', uhd_usrp_sink_0_0_3_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', uhd_usrp_sink_0_0_3_0, '1']
- [blocks_complex_to_interleaved_short_0_0_0, '0', uhd_usrp_sink_0_0_3_0, '2']
- [blocks_complex_to_interleaved_short_0_0_0_0, '0', uhd_usrp_sink_0_0_3_0, '3']
- [blocks_interleaved_short_to_complex_0_0, '0', magProbeD, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', magProbeC, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_interleaved_short_to_complex_0_0_1, '0', magProbeB, '0']
- [blocks_interleaved_short_to_complex_0_0_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_interleaved_short_to_complex_0_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', magProbeA, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', qtgui_freq_sink_x_0_0_2, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', MagNumberA, '0']
- [blocks_nlog10_ff_0_0, '0', MagNumberB, '0']
- [blocks_nlog10_ff_0_0_0, '0', MagNumberC, '0']
- [blocks_nlog10_ff_0_0_0_0, '0', MagNumberD, '0']
- [magProbeA, '0', blocks_nlog10_ff_0, '0']
- [magProbeB, '0', blocks_nlog10_ff_0_0, '0']
- [magProbeC, '0', blocks_nlog10_ff_0_0_0, '0']
- [magProbeD, '0', blocks_nlog10_ff_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_interleaved_short_to_complex_0_0_2, '0']
- [uhd_usrp_source_0_0, '1', blocks_interleaved_short_to_complex_0_0_1, '0']
- [uhd_usrp_source_0_0, '2', blocks_interleaved_short_to_complex_0_0_0, '0']
- [uhd_usrp_source_0_0, '3', blocks_interleaved_short_to_complex_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
